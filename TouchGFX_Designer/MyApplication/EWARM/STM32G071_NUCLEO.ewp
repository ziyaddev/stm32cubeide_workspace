# IAR project STM32G071_NUCLEO.ewp, settings and files
configuration STM32G071_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071RB ST STM32G071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G071xx; USE_BPP=16
  ICCARM.CCIncludePath2: ../TouchGFX/App; ../TouchGFX/target/generated; ../TouchGFX/target; ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/ST/touchgfx/framework/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/gui/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: STM32G071_NUCLEO.hex
  ILINK.IlinkOutputFile: STM32G071_NUCLEO.out
  ILINK.IlinkIcfFile: stm32g071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: STM32G071_NUCLEO.ipcf stm32g071xx_flash.icf
  group Application/EWARM
    ./: startup_stm32g071xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXDataReader.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp TouchGFXGeneratedDataReader.cpp OSWrappers.cpp
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/MB1642B
    ../Core/Src/: MB1642BDisplayDriver.c MB1642BDataReader.c MB1642BButtonController.cpp
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_Amiri_Regular_18_2bpp_0.cpp Font_Amiri_Regular_18_2bpp_31.cpp Font_Amiri_Regular_22_4bpp_0.cpp Font_chinese_msyh_14_4bpp_0.cpp Font_chinese_msyh_14_4bpp_12.cpp Font_chinese_msyh_14_4bpp_14.cpp Font_chinese_msyh_14_4bpp_17.cpp Font_chinese_msyh_14_4bpp_6.cpp Font_chinese_msyh_14_4bpp_9.cpp Font_chinese_msyh_20_4bpp_0.cpp Font_chinese_msyh_20_4bpp_10.cpp Font_chinese_msyh_20_4bpp_11.cpp Font_chinese_msyh_20_4bpp_12.cpp Font_chinese_msyh_20_4bpp_13.cpp Font_chinese_msyh_20_4bpp_14.cpp Font_chinese_msyh_20_4bpp_15.cpp Font_chinese_msyh_20_4bpp_17.cpp Font_chinese_msyh_20_4bpp_18.cpp Font_chinese_msyh_20_4bpp_6.cpp Font_chinese_msyh_20_4bpp_9.cpp Font_NanumGothic_14_4bpp_0.cpp Font_NanumGothic_14_4bpp_21.cpp Font_NanumGothic_14_4bpp_24.cpp Font_NanumGothic_14_4bpp_25.cpp Font_NanumGothic_14_4bpp_26.cpp Font_NanumGothic_20_4bpp_0.cpp Font_NanumGothic_20_4bpp_22.cpp Font_NanumGothic_20_4bpp_23.cpp Font_NanumGothic_20_4bpp_24.cpp Font_NanumGothic_20_4bpp_26.cpp Font_NanumGothic_30_4bpp_0.cpp Font_verdana_14_4bpp_0.cpp Font_verdana_20_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_Amiri_Regular_18_2bpp.cpp Kerning_Amiri_Regular_22_4bpp.cpp Kerning_chinese_msyh_14_4bpp.cpp Kerning_chinese_msyh_20_4bpp.cpp Kerning_NanumGothic_14_4bpp.cpp Kerning_NanumGothic_20_4bpp.cpp Kerning_NanumGothic_30_4bpp.cpp Kerning_verdana_14_4bpp.cpp Kerning_verdana_20_4bpp.cpp Table_Amiri_Regular_18_2bpp.cpp Table_Amiri_Regular_22_4bpp.cpp Table_chinese_msyh_14_4bpp.cpp Table_chinese_msyh_20_4bpp.cpp Table_NanumGothic_14_4bpp.cpp Table_NanumGothic_20_4bpp.cpp Table_NanumGothic_30_4bpp.cpp Table_verdana_14_4bpp.cpp Table_verdana_20_4bpp.cpp UnmappedDataFont.cpp
  group TouchGFX/generated/gui_generated
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../TouchGFX/generated/gui_generated/src/graph_screen/: GraphViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/image_screen/: ImageViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/info_screen/: InfoViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/containers/: languageSelectorElementBase.cpp languageSelectorElementCenterBase.cpp
    ../TouchGFX/generated/gui_generated/src/list_screen/: ListViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
  group TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp image_flags.cpp image_flagsDimmed.cpp image_image0.cpp image_image01.cpp image_image02.cpp image_infoBackground.cpp image_infoBackground2.cpp image_joystick_overlay.cpp image_leftArrow.cpp image_leftArrowDark.cpp image_listBackground.cpp image_logo_00.cpp image_logo_01.cpp image_rightArrow.cpp image_rightArrowDark.cpp image_subDemoIcon_Graph.cpp image_subDemoIcon_Image.cpp image_subDemoIcon_Info.cpp image_subDemoIcon_List.cpp image_subtitle.cpp
    ../TouchGFX/generated/images/src/flags/: image_china-flag-small.cpp image_denmark-flag-small.cpp image_france-flag-small.cpp image_japan-flag-small.cpp image_south-korea-flag-small.cpp image_tunisia-flag-small.cpp image_united-kingdom-flag-small.cpp
  group TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageCn.cpp LanguageDk.cpp LanguageFr.cpp LanguageGb.cpp LanguageJp.cpp LanguageKr.cpp LanguageTn.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: languageSelectorElement.cpp languageSelectorElementCenter.cpp
  group TouchGFX/gui/graph_screen
    ../TouchGFX/gui/src/graph_screen/: GraphPresenter.cpp GraphView.cpp
  group TouchGFX/gui/image_screen
    ../TouchGFX/gui/src/image_screen/: ImagePresenter.cpp ImageView.cpp
  group TouchGFX/gui/info_screen
    ../TouchGFX/gui/src/info_screen/: InfoPresenter.cpp InfoView.cpp
  group TouchGFX/gui/list_screen
    ../TouchGFX/gui/src/list_screen/: ListPresenter.cpp ListView.cpp
  group TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group TouchGFX/gui/screen1_screen
    ../TouchGFX/gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
  group TouchGFX/Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m0/IAR8.x/: touchgfx_core.a
