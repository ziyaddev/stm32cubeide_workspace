# Keil uVision project Project.uvprojx, settings and files
target PredictiveMaintenance (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NUCLEO-F446RE_PredictiveMaintenance.bin +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32F4XX_NUCLEO,STM32_NUCLEO,__FPU_PRESENT=1U,ARM_MATH_CM4
  c include: ..\Inc;..\Patch;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\CCA02M2;..\..\..\..\..\Drivers\BSP\IKS01A3;..\..\..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\Drivers\BSP\Components\ism330dlc;..\..\..\..\..\Drivers\BSP\Components\lps22hh;..\..\..\..\..\Drivers\BSP\Components\lis2mdl;..\..\..\..\..\Drivers\BSP\Components\lsm6dso;..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager;..\..\..\..\..\Middlewares\ST\STM32_MotionSP_Library\Inc;..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc;..\..\..\..\..\Middlewares\ST\BlueNRG-2\includes;..\..\..\..\..\Middlewares\ST\BlueNRG-2\utils;..\..\..\..\..\Middlewares\ST\BlueNRG-2\hci\hci_tl_patterns\Basic;..\..\..\..\..\Middlewares\ST\STM32_BLE_Manager\Inc;..\..\..\..\..\Middlewares\Third_Party\parson
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ./: startup_stm32f446xx.s
  group User/Patch
    ../Patch/: iks01a3_motion_sensors_ex_Patch.c iks01a3_motion_sensors_Patch.c ism330dlc_Patch.c
  group User
    ../Src/: BLE_Implementation.c hci_tl_interface.c main.c MotionSP_Manager.c OTA.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_nucleo.c stm32f4xx_nucleo_bus.c TargetPlatform.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/IKS01A3
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
  group Drivers/BSP/Components/ism330dlc
    ../../../../../Drivers/BSP/Components/ism330dlc/: ism330dlc.c ism330dlc_reg.c
  group Drivers/BSP/X-NUCLEO-CCAM02M2
    ../../../../../Drivers/BSP/CCA02M2/: cca02m2_audio.c
  group Drivers/BSP/X-NUCLEO-IKS01A3
    ../../../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_wwdg.c
  group Middlewares/BlueNRG-2
    ../../../../../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/json
    ../../../../../Middlewares/Third_Party/parson/: parson.c
  group Middlewares/STM32_MetaDataManager
    ../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/ST/STM32_Audio_PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Middlewares/STM32_BLE_Manager
    ../../../../../Middlewares/ST/STM32_BLE_Manager/Src/: BLE_AudioLevel.c BLE_Environmental.c BLE_FFT_AlarmAccPeakStatus.c BLE_FFT_AlarmSpeedStatus.c BLE_FFT_AlarmSubrangeStatus.c BLE_FFT_Amplitude.c BLE_Inertial.c BLE_Manager.c BLE_TimeDomain.c
  group Middlewares/ST/STM32_MotionSP_Library
    ../../../../../Middlewares/ST/STM32_MotionSP_Library/Src/: MotionSP.c
  group CMSIS
    ../../../../../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
